# IAR project 03oos_openwsn.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\at86rf231\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\gina\; ..\..\..\drivers\common\; ..\..\..\drivers\gina\; ..\..\..\kernel\openos\; ..\..\..\inc\; ..\..\..\openstack\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openstack\cross-layers\; ..\..\..\openapps\; ..\..\..\openapps\c6t\; ..\..\..\openapps\cinfo\; ..\..\..\openapps\cleds\; ..\..\..\openapps\cwellknown\; ..\..\..\openapps\techo\; ..\..\..\openapps\tohlone\; ..\..\..\openapps\uecho\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/03oos_openwsn/: 03oos_openwsn.c 03oos_openwsn.h
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h uart.h
  group bsp/boards/gina
    ../../../bsp/boards/gina/: board.c board_info.h bsp_timer.c debugpins.c eui64.c i2c.c leds.c radiotimer.c spi.c uart.c
    ../../../drivers/gina/: gyro.c gyro.h large_range_accel.c large_range_accel.h magnetometer.c magnetometer.h sensitive_accel_temperature.c sensitive_accel_temperature.h
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: at86rf231.h radio.c
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group drivers/gina
    ../../../drivers/gina/: ADC_Channel.c ADC_Channel.h
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/openos/: scheduler.c scheduler.h
  group openapps
    ../../../openapps/: openapps.c
  group openapps/c6t
    ../../../openapps/c6t/: c6t.c c6t.h
  group openapps/cinfo
    ../../../openapps/cinfo/: cinfo.c cinfo.h
  group openapps/cleds
    ../../../openapps/cleds/: cleds.c cleds.h
  group openapps/cwellknown
    ../../../openapps/cwellknown/: cwellknown.c cwellknown.h
  group openapps/techo
    ../../../openapps/techo/: techo.c techo.h
  group openapps/tohlone
    ../../../openapps/tohlone/: tohlone.c tohlone.h tohlone_webpages.c tohlone_webpages.h
  group openapps/uecho
    ../../../openapps/uecho/: uecho.c uecho.h
  group openstack
    ../../../openstack/: openstack.c openstack.h
  group openstack/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openstack/02b-MAChigh
    ../../../openstack/02b-MAChigh/: neighbors.c neighbors.h otf.c otf.h processIE.c processIE.h schedule.c schedule.h sixtop.c sixtop.h
  group openstack/03a-IPHC
    ../../../openstack/03a-IPHC/: iphc.c iphc.h openbridge.c openbridge.h
  group openstack/03b-IPv6
    ../../../openstack/03b-IPv6/: forwarding.c forwarding.h icmpv6.c icmpv6.h icmpv6echo.c icmpv6echo.h icmpv6rpl.c icmpv6rpl.h
  group openstack/04-TRAN
    ../../../openstack/04-TRAN/: opencoap.c opencoap.h opentcp.c opentcp.h openudp.c openudp.h
  group openstack/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
